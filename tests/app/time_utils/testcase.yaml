## tests/app/time_utils/testcase.yaml
```yaml
common:
  tags: app time
  integration_platforms:
    - native_sim
tests:
  app.time_utils: {}
```
